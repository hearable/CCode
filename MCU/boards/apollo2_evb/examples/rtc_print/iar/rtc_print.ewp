# IAR project rtc_print.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\src; ..\..\..\bsp; ..\..\..\..\..\utils; ..\..\..\..\..\devices; ..\..\..\..\..\mcu\apollo2; ..\..\..\..\..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rtc_print.bin
  ILINK.IlinkOutputFile: rtc_print.out
  ILINK.IlinkIcfFile: rtc_print.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo2\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO2
  group (top)
    ../src/: rtc_print.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c am_util_string.c am_util_time.c
    ./: startup_iar.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
