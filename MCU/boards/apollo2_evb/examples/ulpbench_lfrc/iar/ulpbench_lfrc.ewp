# IAR project ulpbench_lfrc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AMAPH1KK-KBR AmbiqMicro AMAPH1KK-KBR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: iar; AM_PACKAGE_BGA; AM_PART_APOLLO2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\src; ..\src\benchmarks; ..\src\benchmarks\CoreProfile; ..\src\TES; ..\src\Platforms\ARM\Board; ..\src\Platforms\ARM\Platform; ..\..\..\bsp; ..\..\..\..\..\utils; ..\..\..\..\..\devices; ..\..\..\..\..\mcu\apollo2
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ulpbench_lfrc.bin
  ILINK.IlinkOutputFile: ulpbench_lfrc.out
  ILINK.IlinkIcfFile: ulpbench_lfrc.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\bsp\iar\bin\libam_bsp.a; ..\..\..\..\..\mcu\apollo2\hal\iar\bin\libam_hal.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; iar; AM_PACKAGE_BGA; AM_PART_APOLLO2
  group (top)
    ../src/benchmarks/CoreProfile/: CoreProfile.c lcd.c math_int.c permutation.c sort.c state.c
    ../src/TES/: TesEvents.c TesLists.c TesThreads.c TesTimers.c TesUtil.c
    ../src/Platforms/ARM/Board/: hardware_setup.c retarget.c
    ../src/Platforms/ARM/Platform/: Platform.c PlatformStackSwap.c
    ../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_stdio.c
    ../../../../../devices/: am_devices_led.c
    ./: startup_iar.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
